# Make sure we can unpack fbcfg files
CFLAGS_append_class-target += "-DZIP64_SUPPORT"