RDEPENDS_packagegroup-base-3g = "modemmanager"
RDEPENDS_packagegroup-distro-base_append += "login-welcome"
