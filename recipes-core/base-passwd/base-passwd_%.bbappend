SRC_URI:remove = "file://0008-Add-wheel-group.patch"
