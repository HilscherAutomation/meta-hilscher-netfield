FILESEXTRAPATHS:prepend:="${THISDIR}/files:"
SRC_URI:append:class-target = " file://add_partial_devicelabel_support.patch"
