# Required for pkcs11-proxy-native
BBCLASSEXTEND:append = " native"
