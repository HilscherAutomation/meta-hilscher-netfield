# Required for p11tool to access pkcs11 stores
PACKAGECONFIG:append:class-native = " p11-kit"
