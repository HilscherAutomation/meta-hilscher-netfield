# Required for gnutools-native to access pkcs11 stores
BBCLASSEXTEND_append += "native"
