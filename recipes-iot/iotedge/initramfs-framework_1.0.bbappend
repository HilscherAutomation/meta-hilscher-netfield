RDEPENDS_${PN}-base_append += "initramfs-update-iotedge"
