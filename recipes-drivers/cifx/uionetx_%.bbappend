
inherit module sign-wrapper
