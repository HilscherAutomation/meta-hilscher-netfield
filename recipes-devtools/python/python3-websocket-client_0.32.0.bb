SUMMARY = "WebSocket client for python. hybi13 is supported."
HOMEPAGE = "https://github.com/websocket-client/websocket-client.git"
LICENSE = "LGPL-2.1"
LIC_FILES_CHKSUM = "file://LICENSE;md5=241615fe24b899ca6b6d20b9c4b5dbbd"

inherit pypi setuptools3

PYPI_PACKAGE = "websocket_client"

SRC_URI[sha256sum] = "cb3ab95617ed2098d24723e3ad04ed06c4fde661400b96daa1859af965bfe040"
