SUMMARY = "A decorator for caching properties in classes."
HOMEPAGE = "https://github.com/pydanny/cached-property"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=db7ff60c4e14f58534201242803d8abc"

inherit pypi setuptools3

SRC_URI[sha256sum] = "9217a59f14a5682da7c4b8829deadbfc194ac22e9908ccf7c8820234e80a1504"
