
require libstd-rs.inc

SRC_URI[rust.md5sum] = "a460bed79b92f6a7833ba6e6390ee6ae"
SRC_URI[rust.sha256sum] = "3185df064c4747f2c8b9bb8c4468edd58ff4ad6d07880c879ac1b173b768d81d"

LIC_FILES_CHKSUM = "file://../../COPYRIGHT;md5=93a95682d51b4cb0a633a97046940ef0"
