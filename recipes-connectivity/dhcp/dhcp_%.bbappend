
RDEPENDS_${PN}-client_append += "coreutils"
